# Keil uVision project ENC28J60.uvprojx, settings and files
target ENC28J60 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NRF24L01 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\MALLOC;..\CORE;..\USMART;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\HARDWARE\ENC28J60;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\udp_demo;..\HARDWARE;..\HARDWARE\DHT11;..\HARDWARE\EXTI;..\HARDWARE\ELENGINE;..\HARDWARE\MOTOR
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ELENGINE/: elengine.c
    ../HARDWARE/MOTOR/: motor.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group MALLOC
    ../MALLOC/: malloc.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/udp_demo/: udp_demo.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
